FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

UBOOT_SUFFIX = "img"
SPL_BINARY = "MLO"
